require greeting-simple.inc
DEFAULT_PREFERENCE = "-1"
