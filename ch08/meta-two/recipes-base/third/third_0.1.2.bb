DESCRIPTION = "I am the third recepi"
PR = "r1"
inherit confbuild

