require greeting-simple.inc
