FILESPATH:prepend := "${THISDIR}/files:"
SRC_URI += "file://greeting.patch"
