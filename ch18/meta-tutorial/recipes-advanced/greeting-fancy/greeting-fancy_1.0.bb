SUMMARY = "An alternative implementation of virtual/greeting"
GREETING_IMPLEMENTATION = "fancy"
inherit tutorial-greeting
