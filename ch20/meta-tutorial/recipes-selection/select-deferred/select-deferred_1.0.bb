SUMMARY = "Deferred inheritance sees the later metadata assignment"
CH20_CLASS = "tutorial-select-early"
inherit_defer ${CH20_CLASS}
CH20_CLASS = "tutorial-select-late"
