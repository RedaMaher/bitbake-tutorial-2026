SUMMARY = "Immediate inheritance uses the class expression at this line"
CH20_CLASS = "tutorial-select-early"
inherit ${CH20_CLASS}
CH20_CLASS = "tutorial-select-late"
