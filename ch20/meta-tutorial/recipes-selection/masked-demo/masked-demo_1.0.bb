SUMMARY = "A valid recipe excluded from discovery by the chapter BBMASK"
CH20_SELECTED = "unmasked"
inherit tutorial-selection-output
