SUMMARY = "Newer recipe from the lower-priority tutorial layer"
CH20_SELECTED = "tutorial 2.0"
inherit tutorial-selection-output
