CH20_SELECTED = "late"
inherit tutorial-selection-output
