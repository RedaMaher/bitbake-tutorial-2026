CH20_SELECTED = "early"
inherit tutorial-selection-output
