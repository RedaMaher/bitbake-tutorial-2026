CH20_VARIANT = "alternate"
