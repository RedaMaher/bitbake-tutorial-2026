SUMMARY = "An optional collection activates a dynamic append"
CH20_SELECTED = "without-two"
inherit tutorial-selection-output
