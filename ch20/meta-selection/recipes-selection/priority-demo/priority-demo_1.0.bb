SUMMARY = "Older recipe from the higher-priority selection layer"
CH20_SELECTED = "selection 1.0"
inherit tutorial-selection-output
